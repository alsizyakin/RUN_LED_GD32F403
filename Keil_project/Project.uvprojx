# Keil uVision project Project.uvprojx, settings and files
target GD32F403 (6140000::V6.14::ARMCLANG)
  device: GD32F403RC GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER, __FPU_PRESENT, ARM_MATH_CM4
  c misc: -Wno-register
  c include: ..\..\GD32403R_PUMP;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F403\Include;..\Firmware\GD32F403_standard_peripheral\Include;..\Utilities;..\Peripherals;..\Firmware\CMSIS\DSP\Include;..\Motor_Control;..\..\GD32F403R_PUMP
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application
    ../: main.c
  group Peripherals
    ../Peripherals/: gpio.c rcu.c
  group Utilities
    ../Utilities/: delay.c
  group CMSIS
    ../: system_gd32f403.c
  group SPL
    ../Firmware/GD32F403_standard_peripheral/Source/: gd32f403_dbg.c gd32f403_gpio.c gd32f403_rcu.c
  group Startup
    ../: startup_gd32f403.s
software components: CMSIS:CORE 5.5.0
